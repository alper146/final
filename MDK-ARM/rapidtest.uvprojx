# Keil uVision project rapidtest.uvprojx, settings and files
target rapidtest (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: rapidtest
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32L4xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_usb.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_flash.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_adc.c stm32l4xx_hal_dma.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_i2c_ex.c
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
  group Application/User
    ../Src/: usbd_conf.c usbd_cdc_if.c usbd_desc.c main.c usb_device.c stm32l4xx_it.c stm32l4xx_hal_msp.c
    ../Inc/: rapidtest.c rapidtest.h
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
software components: CMSIS:CORE 4.1.0
